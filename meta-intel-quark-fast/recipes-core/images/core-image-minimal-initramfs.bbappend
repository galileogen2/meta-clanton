FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PACKAGE_INSTALL_quark_quark-fast = "busybox base-passwd udev kernel-module-stmmac"

